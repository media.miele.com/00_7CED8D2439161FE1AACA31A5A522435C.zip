Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: f30dc328-aaa4-4ac1-893f-2882036792b9, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-02T07:22:35+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 13003560_AUS_OCD1216LBL:331B1DCL_AUS_13003560_OCD1216LBL, (2)
In: Default
Type - Material: z_Miele_Design_OBSW
Type - Pset_ProductRequirements - Category: Specialty Equipment
Material: z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Connection_Gas, z_Miele_Connection_Connection_Modul, z_Miele_Connection_Water_OUT, <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 331B1DCL_AUS_13003560_OCD1216LBL; sets with these values: 2
